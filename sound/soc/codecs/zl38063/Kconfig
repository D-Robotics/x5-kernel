## sound/soc/codecs/zl38063/Kconfig
```kconfig
config SND_SOC_ZL38063
	tristate "SoC Audio support for zl380xx codec"
	depends on I2C
	default y
	help
	  Say Y or M here
```
